# Keil uVision project AT32F403A_Project.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.4
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: C:\Users\zed\Desktop\AT32F403A_Library\AT32F403A_407_Firmware_Library_V2.2.2\libraries\drivers\inc;C:\Users\zed\Desktop\AT32F403A_Library\AT32F403A_407_Firmware_Library_V2.2.2\libraries\cmsis\cm4\core_support;C:\Users\zed\Desktop\AT32F403A_Library\AT32F403A_407_Firmware_Library_V2.2.2\libraries\cmsis\cm4\device_support;..\inc;..\bm_arch\Inc;..\app\Inc;..\BSP\GPIO_Driver;..\BSP\SPI_Driver;..\BSP\LCD_Driver;..\BSP\Encoder_Driver;..\BSP\IIC_Driver;..\BSP\KT_Driver;..\BSP\UI_Driver;..\third_party\sgl;..\third_party\sgl\include;..\third_party\sgl\mm\lwmem;C:\Users\zed\Desktop\AT32F403A_Library\AT32F403A_407_Firmware_Library_V2.2.2\project\at32f403a_407_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c bm_hal.c
  group app
    ../app/Src/: main.c app.c lcd_demo.c encoder_demo.c kt_demo.c ui_demo.c
  group bsp_driver
    ../BSP/GPIO_Driver/: gpio.c gpio_port_at32.c
    ../BSP/SPI_Driver/: spi.c spi_port_at32.c
    ../BSP/LCD_Driver/: st7789.c
    ../BSP/Encoder_Driver/: encoder.c
    ../BSP/IIC_Driver/: iic.c iic_port.c iic_port_at32.c
    ../BSP/KT_Driver/: kt0656m.c kt0656m_bus.c
    ../BSP/UI_Driver/: sgl_port_at32.c
  group bm_arch
    ../bm_arch/Src/: scheduler.c msg_queue.c soft_timer.c logger.c app_events.c
  group bsp
    C:/Users/zed/Desktop/AT32F403A_Library/AT32F403A_407_Firmware_Library_V2.2.2/project/at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    C:/Users/zed/Desktop/AT32F403A_Library/AT32F403A_407_Firmware_Library_V2.2.2/libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    C:/Users/zed/Desktop/AT32F403A_Library/AT32F403A_407_Firmware_Library_V2.2.2/libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    C:/Users/zed/Desktop/AT32F403A_Library/AT32F403A_407_Firmware_Library_V2.2.2/libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group sgl_core
    ../third_party/sgl/core/: sgl_anim.c sgl_block.c sgl_core.c sgl_fs.c sgl_event.c sgl_log.c sgl_math.c sgl_snprintf.c
  group sgl_draw
    ../third_party/sgl/draw/: sgl_draw.c sgl_draw_arc.c sgl_draw_bezier.c sgl_draw_circle.c sgl_draw_icon.c sgl_draw_line.c sgl_draw_rect.c sgl_draw_ring.c sgl_draw_slate.c sgl_draw_text.c
  group sgl_font
    ../third_party/sgl/fonts/: sgl_ascii_consolas14.c sgl_ascii_consolas24.c sgl_ascii_consolas32.c sgl_ascii_consolas23.c sgl_ascii_song23.c
  group sgl_mm
    ../third_party/sgl/mm/lwmem/: lwmem.c sgl_mm.c
  group sgl_component
    ../third_party/sgl/components/timer/: sgl_timer.c
    ../third_party/sgl/fs/ramfs/: sgl_ramfs.c
  group sgl_widget
    ../third_party/sgl/widgets/2dball/: sgl_2dball.c
    ../third_party/sgl/widgets/analogclock/: sgl_analogclock.c
    ../third_party/sgl/widgets/arc/: sgl_arc.c
    ../third_party/sgl/widgets/arc_label/: sgl_arc_label.c
    ../third_party/sgl/widgets/bar/: sgl_bar.c
    ../third_party/sgl/widgets/barcode/: sgl_barcode.c
    ../third_party/sgl/widgets/battery/: sgl_battery.c
    ../third_party/sgl/widgets/box/: sgl_box.c
    ../third_party/sgl/widgets/button/: sgl_button.c
    ../third_party/sgl/widgets/calendar/: sgl_calendar.c
    ../third_party/sgl/widgets/canvas/: sgl_canvas.c
    ../third_party/sgl/widgets/charge/: sgl_charge.c
    ../third_party/sgl/widgets/chart/barchart/: sgl_barchart.c
    ../third_party/sgl/widgets/chart/linechart/: sgl_linechart.c
    ../third_party/sgl/widgets/chart/piechart/: sgl_piechart.c
    ../third_party/sgl/widgets/checkbox/: sgl_checkbox.c
    ../third_party/sgl/widgets/circle/: sgl_circle.c
    ../third_party/sgl/widgets/coverflow/: sgl_coverflow.c
    ../third_party/sgl/widgets/curve/: sgl_curve.c
    ../third_party/sgl/widgets/digitalclock/: sgl_digitalclock.c
    ../third_party/sgl/widgets/dropdown/: sgl_dropdown.c
    ../third_party/sgl/widgets/gauge/: sgl_gauge.c
    ../third_party/sgl/widgets/icon/: sgl_icon.c
    ../third_party/sgl/widgets/img/: sgl_img.c
    ../third_party/sgl/widgets/keyboard/: sgl_keyboard.c
    ../third_party/sgl/widgets/label/: sgl_label.c
    ../third_party/sgl/widgets/launcher/: sgl_launcher.c
    ../third_party/sgl/widgets/led/: sgl_led.c
    ../third_party/sgl/widgets/line/: sgl_line.c
    ../third_party/sgl/widgets/menu/: sgl_menu.c
    ../third_party/sgl/widgets/msgbox/: sgl_msgbox.c
    ../third_party/sgl/widgets/numberkbd/: sgl_numberkbd.c
    ../third_party/sgl/widgets/polygon/: sgl_polygon.c
    ../third_party/sgl/widgets/progress/: sgl_progress.c
    ../third_party/sgl/widgets/qrcode/: qrcode.c sgl_qrcode.c
    ../third_party/sgl/widgets/rect/: sgl_rect.c
    ../third_party/sgl/widgets/rect_ext/: sgl_rect_ext.c
    ../third_party/sgl/widgets/ring/: sgl_ring.c
    ../third_party/sgl/widgets/roller/: sgl_roller.c
    ../third_party/sgl/widgets/scope/: sgl_scope.c
    ../third_party/sgl/widgets/scrollview/: sgl_scrollview.c
    ../third_party/sgl/widgets/slider/: sgl_slider.c
    ../third_party/sgl/widgets/slimlabel/: sgl_slimlabel.c
    ../third_party/sgl/widgets/span/: sgl_span.c
    ../third_party/sgl/widgets/spectrum/: sgl_spectrum.c
    ../third_party/sgl/widgets/spinner/: sgl_spinner.c
    ../third_party/sgl/widgets/sprite/: sgl_sprite.c
    ../third_party/sgl/widgets/statusbar/: sgl_statusbar.c
    ../third_party/sgl/widgets/stepper/: sgl_stepper.c
    ../third_party/sgl/widgets/switch/: sgl_switch.c
    ../third_party/sgl/widgets/table/: sgl_table.c
    ../third_party/sgl/widgets/tabview/: sgl_tabview.c
    ../third_party/sgl/widgets/textbox/: sgl_textbox.c
    ../third_party/sgl/widgets/textedit/: sgl_textedit.c
    ../third_party/sgl/widgets/textline/: sgl_textline.c
    ../third_party/sgl/widgets/textlist/: sgl_textlist.c
    ../third_party/sgl/widgets/toast/: sgl_toast.c
    ../third_party/sgl/widgets/viewlist/: sgl_viewlist.c
    ../third_party/sgl/widgets/win/: sgl_win.c
    ../third_party/sgl/widgets/winslate/: sgl_winslate.c
